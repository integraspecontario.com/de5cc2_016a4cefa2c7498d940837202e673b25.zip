Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2016-07-09T17:44:40
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160314_0715(x64) - Exporter 16.4.0.0 - Alternate UI 16.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Jul 09 17:44:40 2016 * Host: BIMdimension_JC * Database: C:\Users\BIMDIM~1\AppData\Local\Temp\{F29D4615-AE1C-4699-A4A3-6C5A3F19B4E8}\ifc * Database version: 5507 * Database creation date: Sat Jul 09 17:44:36 2016 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Jul 09 17:44:36 2016 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Jul 09 17:44:36 2016 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 ft
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 ft
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 1/4" Head
Constraints - Elevation: 0 ft
Dimensions - Computation Height: 0 ft
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 1/4" Head; Family and Type: Level: 1/4" Head; Type: Level: 1/4" Head; Type Id: Level: 1/4" Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Grid Line 1/2"; Line Weight: 1; Symbol: Level Head - Circle: Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Integra Spacer 10 IN, Integra Spacer 10 IN:Integra Spacer 10 IN:801948
In: Level 1
Type - ElementType: Integra Spacer 10 IN
Type - Identity Data(Type) - Description: "The User Friendly ICF” TM (Insulating Concrete Form / Insulated Concrete Form); Manufacturer: IntegraSpec®; Type Comments: BIM library developed by: www.bimdimension.com; Type Name: Integra Spacer 10 IN; URL: http://www.integraspec.com/
Type - Materials and Finishes(Type) - Structural Material: JC_High Impact Polystyrene (HIPS)
Type - Other(Type) - Category: Casework; Family Name: Integra Spacer 10 IN
Pset_ManufacturerTypeInformation - Manufacturer: IntegraSpec®
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 ft
Dimensions - Area: 229.653 ft2; Volume: 14.4322 ft3
Other - Category: Casework; Family: Integra Spacer 10 IN: Integra Spacer 10 IN; Family and Type: Integra Spacer 10 IN: Integra Spacer 10 IN; Type: Integra Spacer 10 IN: Integra Spacer 10 IN; Type Id: Integra Spacer 10 IN: Integra Spacer 10 IN
Phasing - Phase Created: New Construction
